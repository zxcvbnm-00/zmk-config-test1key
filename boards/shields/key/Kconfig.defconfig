## boards/shields/onekey/Kconfig.defconfig
```kconfig
if SHIELD_ONEKEY

config ZMK_KEYBOARD_NAME
    default "OneKey"

endif # SHIELD_ONEKEY
```
